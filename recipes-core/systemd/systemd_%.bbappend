#This will enable the appropriate configurations of systemd.

PACKAGECONFIG_append = " networkd resolved"


